<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ERRS_10_17.ewp</path>
  </project>
  <batchBuild />
</workspace>
